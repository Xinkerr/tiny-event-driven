# Keil uVision project template.uvprojx, settings and files
target template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32L196KCTA HDSC
  pack: HDSC.HC32L19X.1.0.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: template
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\application;..\driver;..\HC32_lib\inc;..\HC32_lib\mcu\common;..\kernel;..\HC32_lib
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group application
    ../application/: main.c
  group driver
    ../driver/: sysclk_drv.c
  group kernel
    ../kernel/: ringbuffer.c tEvent.c
  group hc32_lib
    ../HC32_lib/src/: ddl.c gpio.c flash.c sysctrl.c lpm.c
  group mcu
    ../HC32_lib/mcu/common/: interrupts_hc32l19x.c system_hc32l19x.c
    ../HC32_lib/: startup_hc32l19x.s
software components: CMSIS:CORE 5.1.1
