# IAR project example.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: Lib\inc; application; Peripherals; kernel
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: example.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  ICCSTM8.CCDefines: NDEBUG
  ILINK.IlinkOutputFile: example.out
  group application
    application/: main.c stm8s_conf.h stm8s_it.c stm8s_it.h
  group kernel
    kernel/: ringbuffer.c tEvent.c
  group Lib
    Lib/src/: stm8s_awu.c stm8s_clk.c stm8s_gpio.c stm8s_tim4.c stm8s_uart1.c
  group Peripherals
    Peripherals/: app_tim4.c LED.c uart.c wakeup_timer.c
